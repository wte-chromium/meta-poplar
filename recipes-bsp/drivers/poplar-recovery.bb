SRCDATE = "20191209"

require poplar-recovery.inc

COMPATIBLE_MACHINE = "poplar"
