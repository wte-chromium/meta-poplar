SRCDATE = "20191209"

require poplar-libs.inc

COMPATIBLE_MACHINE = "poplar"
