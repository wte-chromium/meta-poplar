SRCDATE = "20191209"

require poplar-mali-midgard.inc

COMPATIBLE_MACHINE = "poplar"
